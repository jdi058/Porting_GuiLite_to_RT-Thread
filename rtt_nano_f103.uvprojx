# Keil uVision project rtt_nano_f103.uvprojx, settings and files
target rtt_nano_f103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtt_nano_f103 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: -O1 -g -W
  c include: .\lib\inc;.\startup;.\startup\sys;.\driver;.\rtthread;.\rtthread\components\finsh;.\rtthread\include;.\rtthread\include\libc;.\config;.\uicode
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/: main.c
  group protocol
    ./protocol/: uart.c spi_sim.c
  group driver
    ./driver/: st7735s.c
  group lib
    ./lib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c
  group startup
    ./startup/: core_cm3.c startup_stm32f10x_md.s
    ./startup/sys/: stm32f10x_it.c system_stm32f10x.c
  group sys
    ./rtthread/: board.c rtconfig.h
    ./config/: config.h
  group rtt_kernel
    ./rtthread/kernel/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtt_component
    ./rtthread/components/finsh/: cmd.c msh.c shell.c
  group rtt_ports
    ./rtthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group uicode
    ./uicode/: UIcode.cpp
